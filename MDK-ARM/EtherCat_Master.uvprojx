# Keil uVision project EtherCat_Master.uvprojx, settings and files
target EtherCat_Master (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: EtherCat_Master +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --gnu
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\SOEM\app;..\SOEM\osal;..\SOEM\oshw;..\SOEM\soem;..\BSP;..\BSP\TOUCH;..\BSP\LCD;..\BSP\PCF8574;..\BSP\KEY;..\BSP\IIC;..\BSP\24CXX;..\BSP\SDRAM;..\Middlewares\MALLOC;..\Middlewares\USMART
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group SOEM
    ../SOEM/soem/: ethercatbase.c ethercatcoe.c ethercatconfig.c ethercatdc.c ethercateoe.c ethercatfoe.c ethercatmain.c ethercatprint.c ethercatsoe.c
  group OSAL
    ../SOEM/osal/: osal.c
  group OSHW
    ../SOEM/oshw/: nicdrv.c oshw.c
  group APP
    ../SOEM/app/: DcSync.c ioR5test.c servoS7test.c servotest.c simpletest.c slaveinfo.c za8iotest.c
  group BSP
    ../BSP/24CXX/: 24cxx.c
    ../BSP/KEY/: key.c
    ../BSP/LCD/: ltdc.c lcd.c
    ../BSP/PCF8574/: pcf8574.c
    ../BSP/SDRAM/: sdram.c
    ../BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
    ../BSP/IIC/: myiic.c
    ../SOEM/app/: LD3M_ec7010.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c eth.c memorymap.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_ltdc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middle
    ../Middlewares/MALLOC/: malloc.c
    ../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
software components: CMSIS:CORE 4.3.0
